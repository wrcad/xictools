* Generated by Xic from cell sk03_JJmodel_circ13

* Another Steve Kaplan design, part of an effort to model a neural
* network with JJs by Ken Segall.  Search below for "SRW", I had to
* change a source to obtain phase-mode DCOP convergence.

* Set this to 0 to use TRAN ramp-up and uic instead of DCOP.
.param dcop=1

.control
# This is not portable, we need to reset these parameters from the
# deck values before running.

alter I0, dc=0.00225
alter I3, dc=0.00225
alter I1, dc=0.00215
alter I2, dc=0.00215
alter Isrc_left.X3, dc=1.0E-05
alter Isrc_left.X27, dc=1.0E-05
alter I00.X3, dc=0.00057
alter I00.X27, dc=0.00057
alter I4, dc=0.000915

ibias = 0.033E-03
imagnet = 1.6E-03
alter Ibias.X1.X5, dc=$&ibias
alter Ibias.X1.X19, dc=$&ibias
alter Imagnet.X1.X5, dc=$&imagnet
alter Imagnet.X1.X19, dc=$&imagnet
run
plot ysep v(1.x44) v(1.x42) v(1.x43)
.endc

.if dcop
.tran .05p 20ns 18ns
.else
.tran .05p 20ns 18ns uic
.endif

.plot tran v(1.x44) v(1.x42) v(1.x43)
*@ set maxdata=4E8
I0 0 3 2.00m
I1 0 34 1.90m
I2 0 21 1.90m
I3 0 19 2.00m
I4 0 47 .82m
X0 1 2 3 sk03_jtl2j2_4bfc_feedthru
X1 4 1 3 sk03_jtl2j2l_4bfc
X2 5 2 3 sk03_jtl2j2l_4bfc
X3 6 7 8 9 sk03_neuron
X4 10 11 3 sk03_jtl2j2_4bfc_feedthru
X5 12 3 6 sk03_synapse_wJTL
X6 10 13 3 sk03_jtl2j2l_4bfc_spec
X7 11 4 3 sk03_jtl2j2l_4bfc
X8 12 5 3 sk03_jtl2j2l_4bfc
X9 14 13 3 sk03_jtl1j2_4bfc
X10 3 15 16 14 sk03_oneD_JTL_4bfc_l
X11 17 18 7 19 sk03_spl2j2f_4bfc_m1gap
X12 17 20 21 sk03_jtl2j2l_m1gap
X13 19 22 18 23 sk03_oneD_JTL_4bfc_l
X14 24 20 21 sk03_jtl2j2
X15 25 24 21 sk03_jtl2j2
X16 26 27 19 sk03_jtl2j2_4bfc
X17 28 26 19 sk03_jtl2j2l_4bfc
X18 29 27 19 sk03_jtl2j2l_4bfc
X19 30 19 31 sk03_synapse_wJTL
X20 32 33 34 sk03_jtl2j2l_m1gap
X21 32 16 35 15 sk03_spl2j2f_4bfc_m1gap
X22 36 21 25 37 sk03_oneD_JTL
X23 23 38 19 sk03_jtl1j2_4bfc
X24 30 28 19 sk03_jtl2j2l_4bfc
X25 39 29 19 sk03_jtl2j2l_4bfc
X26 40 38 19 sk03_jtl2j2l_4bfc_spec
X27 31 35 41 42 sk03_neuron
X28 39 40 19 sk03_jtl2j2_4bfc
X29 43 33 34 sk03_jtl2j2_140um
X30 43 44 34 sk03_jtl2j2l
X31 45 46 47 48 sk03_cb_4bfc_evenL
X32 49 50 51 52 sk03_spl2j2f_5umoff
X33 53 54 55 21 sk03_spl2j2f_str
X34 55 37 21 sk03_jtl2j2l
X35 52 34 44 56 sk03_oneD_JTL
X36 56 51 52 sk03_jtl2j2_feedthru
X37 49 45 52 sk03_jtl2j2_130um
X38 46 53 21 sk03_jtl2j2_140um
X39 57 50 52 sk03_jtl2j2
X40 58 54 21 sk03_jtl2j2
X41 59 48 47 sk03_jtl2j2
X42 57 sktv_std_sfqtrm_wM3
X43 58 sktv_std_sfqtrm_wM3
X44 59 sktv_std_sfqtrm_wM3
.subckt sk03_Rb_3p80pu _0 _1
R0 _0 _1 4.7ohms
.ends sk03_Rb_3p80pu
.subckt sk03_jtl2j2l_m1gap _0 _1 _2
L1c 8 5 1.995pH
L2c 5 2 2.001pH
LPVb 3 5 2.4pH
Lin _0 7 2.137pH
Lout 1 _1 2.124pH
X0 1 2 sk03_p2j001v43lb
X1 3 _2 sk03_Rb_3p00pu
X2 7 8 sk03_p2j001v43lb
.ends sk03_jtl2j2l_m1gap
.subckt sk03_p2j60lb _0 _0 _2
B1 _0 _2 1 jj02 area=2.60
Rb1 _0 _2 1.62ohm
.ends sk03_p2j60lb
.subckt sk03_p2j601v43lb _0 _0
B0 _0 2 1 jj02 area=2.60
LRb 4 0 0.232pH
Lj 2 0 0.14pH
Rb _0 4 2.32ohm
.ends sk03_p2j601v43lb
.subckt sk03_synapse Vb Ic In Out
BJ1 8 0 10 jj02 area=1.00
BJ2 9 0 12 jj02 area=1.00
Ibias 0 Vb 0.11mA
Imagnet 0 Ic 0.0mA
K1 Lc L1 0.233
K2 L2 Lc 0.233
L0 In 4 2.065pH
L1 8 5 1.98pH
L2 5 9 1.98pH
LP0 4 5 0.89pH
LP1 5 11 4.14pH
LQ0 4 1 3.039pH
Lc Ic 7 3.621pH
R0 8 0 6
R1 9 0 6
RLIc 7 0 5ohm
RVb 11 Vb 10.5ohm
X0 1 Out sk03_rcap433f
.ends sk03_synapse
.subckt sk03_jtl2j2l_4bfc_spec _0 _1 _2
L1c 8 5 1.995pH
L2c 5 2 2.001pH
LPVb 3 5 2.4pH
Lin _0 7 2.137pH
Lout 1 _1 2.124pH
X0 1 2 sk03_p2j001v43lb
X1 3 _2 sk03_Rb_3p00pu
X2 7 8 sk03_p2j001v43lb
.ends sk03_jtl2j2l_4bfc_spec
.subckt sktv_std_sfqtrm_wM3 _0
LP0 3 0 0.15pH
Lterm 1 _0 0.5pH
Rterm 1 3 2.9ohms
.ends sktv_std_sfqtrm_wM3
.subckt sk03_p2j01lb _0 _0 _2
B0 _0 _2 1 jj02 area=2.01
Rb _0 _2 2.1ohm
.ends sk03_p2j01lb
.subckt sk03_cb_4bfc_evenL INB INA Vb OUT
LA1 1 INA 2.154p
LA3 5 3 0.858p
LB1 18 INB 2.076p
LB3 14 17 0.826p
LPbias 12 11 1.131p
Lout1 8 11 1.137p
Lout3 11 9 3.348p
Lout4 10 OUT 2.080p
LpJA1 4 0 0.149p
LpJAB 6 0 0.195p
LpJB1 19 0 0.230p
R0 Vb 12 4.13ohms
X0 1 3 4 sk03_p2j01sb
X1 5 7 8 sk03_p1j90s
X2 9 10 6 sk03_p2j01lb
X3 14 15 8 sk03_p1j90s
X4 18 17 19 sk03_p2j01sb
.ends sk03_cb_4bfc_evenL
.subckt sk03_p2j001v43lb _0 _0
B0 _0 2 1 jj02 area=2.00
LRb 4 0 0.15pH
Lj 2 0 0.14pH
Rb _0 4 3ohm
.ends sk03_p2j001v43lb
.subckt sk03_spl2j2f_str Out1 Out2 In _3
L1 In 7 2.28pH
L1c 8 5 2.08pH
L2c 5 9 1.49pH
L4 3 Out1 2.86pH
LPVb 1 5 2.54pH
Lj 10 0 0.14pH
Lj2p 11 0 0.14pH
Lout2 3 Out2 3.185pH
X0 1 _3 sk03_Rb_3p80pu
X1 7 8 10 sk03_p2j01lb
X2 9 3 11 sk03_p2j60lb
.ends sk03_spl2j2f_str
.subckt sk03_Rb_3p00pu _0 _1
RVb _0 _1 5.6ohms
.ends sk03_Rb_3p00pu
.subckt sk03_jtl2j2_140um _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 10 3.pH
Lin _0 2 1.99pH
Lj1p 8 0 0.132pH
Lj2p 9 0 0.127pH
Lout 6 _1 1.99pH
X0 3 2 8 sk03_p2j01lb
X1 5 6 9 sk03_p2j01lb
X2 10 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2_140um
.subckt sk03_jtl2j2_130um _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 10 3.pH
Lin _0 2 1.99pH
Lj1p 8 0 0.132pH
Lj2p 9 0 0.127pH
Lout 6 _1 1.99pH
X0 3 2 8 sk03_p2j01lb
X1 5 6 9 sk03_p2j01lb
X2 10 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2_130um
.subckt sk03_neuron IN OUT Vb1 Vb2
B2 10 0 11 jj02 area=1.2
BJ1 IN 7 8 jj02 area=1.2
BJout 0 4 9 jj02 area=2.00

.if dcop
* SRW - Delay this so DCOP converges
I00 0 Vb2 pulse 0 0.54mA 1p 1p
.else
I00 0 Vb2 0.54mA
.endif

Isrc_left 0 Vb1 0.019mA
LQ0 IN 0 11.071pH
LQ1 2 10 10.953pH
Lj 2 4 0.104pH
Lout OUT 4 1.948pH
Lx 7 2 0.715pH
RVb Vb2 2 4.2ohm
RVb1 Vb1 IN 5.0ohm
RsJout 4 0 3ohm
Rsj1 IN 7 3ohm
Rsj2 10 0 3ohm
.ends sk03_neuron
.subckt sk03_oneD_JTL Vb1 Vb1 In Out
L10 18 19 2.01pH
L1c 8 9 2.00pH
L2c 9 10 2.01pH
L4 11 5 1.943pH
L5 4 12 2.049pH
L6a 1 2 1.678pH
L6b 2 3 2.672pH
L7 13 14 3.988pH
L8 15 16 1.99pH
L9 17 18 2.00pH
Lin In 7 1.99pH
Lj1p 22 0 0.132pH
Lj2p 23 0 0.127pH
Lj5p 25 0 0.137pH
Lj6p 26 0 0.14pH
Lj7p 27 0 0.132pH
Lj8p 28 0 0.127pH
Lout 20 Out 1.99pH
X0 4 5 1 sk03_p1j80l
X1 8 7 22 sk03_p2j01lb
X2 10 11 23 sk03_p2j01lb
X3 12 24 0 sk03_p2j01lb
X4 3 13 25 sk03_p2j01lb
X5 15 14 26 sk03_p2j01lb
X6 17 16 27 sk03_p2j01lb
X7 19 20 28 sk03_p2j01lb
X8 9 Vb1 sk03_Rb_3p00pu
X9 Vb1 2 sk03_Rb_2p40pu
X10 18 Vb1 sk03_Rb_3p00pu
.ends sk03_oneD_JTL
.subckt sk03_Rb_2p40pu _0 _1
RVb _0 _1 7.0ohms
.ends sk03_Rb_2p40pu
.subckt sk03_p1j80l _0 _0 _2
B1 _0 _2 1 jj02 area=1.80
Rb1 _0 _2 2.34ohm
.ends sk03_p1j80l
.subckt sk03_p1j90s _0 _0 _2
B0 _0 _2 1 jj02 area=1.90
Rb _0 _2 2.22ohm
.ends sk03_p1j90s
.subckt sk03_rcap433f _0 _1
C1 1 0 217fF
C2 3 0 217fF
R1 _0 1 0.05ohm
R2 1 3 0.05ohm
Rout _1 3 7ohm
.ends sk03_rcap433f
.subckt sk03_jtl2j2_4bfc_feedthru _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 8 3.pH
Lin _0 2 1.99pH
Lout 6 _1 1.99pH
X0 2 3 sk03_p2j001v43lb
X1 6 5 sk03_p2j001v43lb
X2 8 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2_4bfc_feedthru
.subckt sk03_oneD_JTL_4bfc_l Vb1 Vb1 In Out
L10 21 6 2.01pH
L1c 11 12 2.00pH
L2c 12 13 2.01pH
L4 14 8 1.943pH
L5 7 15 2.049pH
L6a 3 4 1.678pH
L6b 4 5 2.672pH
L7 16 17 3.988pH
L8 18 19 1.99pH
L9 20 21 2.00pH
LP00 12 24 3.pH
LP01 23 4 0.78pH
LP02 21 25 3.pH
Lin In 10 1.99pH
Lout 1 Out 1.99pH
X0 6 1 sk03_p2j001v43lb
X1 7 8 3 sk03_p1j80l
X2 11 10 sk03_p2j001v43lb
X3 13 14 sk03_p2j001v43lb
X4 15 22 sk03_p2j001v43lb
X5 5 16 sk03_p2j001v43lb
X6 18 17 sk03_p2j001v43lb
X7 20 19 sk03_p2j001v43lb
X8 24 Vb1 sk03_Rb_3p00pu
X9 Vb1 23 sk03_Rb_2p40pu
X10 25 Vb1 sk03_Rb_3p00pu
.ends sk03_oneD_JTL_4bfc_l
.subckt sk03_jtl2j2l _0 _1 _2
L1c 8 5 1.995pH
L2c 5 2 2.001pH
LPVb 3 5 2.4pH
Lin _0 7 2.137pH
Lout 1 _1 2.124pH
X0 1 2 sk03_p2j001v43lb
X1 3 _2 sk03_Rb_3p00pu
X2 7 8 sk03_p2j001v43lb
.ends sk03_jtl2j2l
.subckt sk03_jtl2j2_4bfc _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 8 3.pH
Lin _0 2 1.99pH
Lout 6 _1 1.99pH
X0 2 3 sk03_p2j001v43lb
X1 6 5 sk03_p2j001v43lb
X2 8 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2_4bfc
.subckt sk03_jtl1j2_4bfc _0 _1 Vb
L1c 5 _1 1.995pH
Lin _0 3 2.01pH
X0 1 Vb sk03_Rb_3p00pu
X1 3 1 sk03_Rb_3p00pu
X2 3 5 sk03_p2j001v43lb
.ends sk03_jtl1j2_4bfc
.subckt sk03_synapse_wJTL IN Vb OUT
X0 IN 2 Vb sk03_jtl2j2l
X1 4 5 2 OUT sk03_synapse
.ends sk03_synapse_wJTL
.subckt sk03_p2j01sb _0 _0 _2
B0 _0 _2 1 jj02 area=2.01
Rb _0 _2 2.1ohm
.ends sk03_p2j01sb
.subckt sk03_jtl2j2l_4bfc _0 _1 _2
L1c 8 5 1.995pH
L2c 5 2 2.001pH
LPVb 3 5 2.4pH
Lin _0 7 2.137pH
Lout 1 _1 2.124pH
X0 1 2 sk03_p2j001v43lb
X1 3 _2 sk03_Rb_3p00pu
X2 7 8 sk03_p2j001v43lb
.ends sk03_jtl2j2l_4bfc
.subckt sk03_jtl2j2 _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 10 3.pH
Lin _0 2 1.99pH
Lj1p 8 0 0.132pH
Lj2p 9 0 0.127pH
Lout 6 _1 1.99pH
X0 3 2 8 sk03_p2j01lb
X1 5 6 9 sk03_p2j01lb
X2 10 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2
.subckt sk03_spl2j2f_4bfc_m1gap Out1 Out2 In _3
L1 In 7 2.28pH
L1c 8 5 2.08pH
L2c 5 9 1.49pH
L4 3 Out1 2.86pH
LPVb 1 5 2.54pH
Lout2 3 Out2 3.185pH
X0 1 _3 sk03_Rb_3p80pu
X1 7 8 sk03_p2j001v43lb
X2 9 3 sk03_p2j601v43lb
.ends sk03_spl2j2f_4bfc_m1gap
.subckt sk03_spl2j2f_5umoff Out1 Out2 In _3
L1 In 7 2.28pH
L1c 8 5 2.08pH
L2c 5 9 1.49pH
L4 3 Out1 2.86pH
LPVb 1 5 2.54pH
Lj1p 10 0 0.132pH
Lj2p 11 0 0.1pH
Lout2 3 Out2 3.185pH
X0 1 _3 sk03_Rb_3p80pu
X1 7 8 10 sk03_p2j01lb
X2 9 3 11 sk03_p2j60lb
.ends sk03_spl2j2f_5umoff
.subckt sk03_jtl2j2_feedthru _0 _1 Vb
L1c 3 4 2.00pH
L2c 4 5 2.01pH
LP0 4 10 3.pH
Lin _0 2 1.99pH
Lj1p 8 0 0.132pH
Lj2p 9 0 0.127pH
Lout 6 _1 1.99pH
X0 3 2 8 sk03_p2j01lb
X1 5 6 9 sk03_p2j01lb
X2 10 Vb sk03_Rb_3p00pu
.ends sk03_jtl2j2_feedthru
.model jj02 jj(rtype=1, cct=1, icon=10m, vg=2.6m, delv=0.08m
+ icrit=0.098m, r0=240, rn=13.1765, cap=0.163p)
*Nb 4500 A/cm^2  RSFQ-style normalized JJ to 0.125mA A=2.777 um^2,C=58.52fF/um^2
