* Generated by Xic from cell SK_PMADC_FRONT

* Not sure what this is exactly, but it represents a rather complex circuit
* suitable for use as a benchmark.  Author: Steve Kaplan, Estes Park, CO
*
* Warning:  This file probably requires WRspice-4.3.3 or later.

.control
tran 1ps 10ns
plot ysep v(7.x6) v(8) v(9.x11) v(6.x11) v(8.x10) v(8.x6.x8) Lin.x9#branch
.endc

* Below,
* Level=1 selects the internal JJ model.
* Level=2 selects the example Verilog-A JJ model, if loaded (with
* the devload command).
*
.model jj1000 jj(level=1)

*@ set maxdata=2E8
I1 0 24 sin(.05mA .100mA 10GHz 0 0)
Isig 0 23 sin(0 0.01mA 0.51GHz 0ps 0.0s)
Lend 19 20 2pH
R0 20 0 2ohm
R1 0 OUT1 2ohms
X0 14 OUT3 SKQ2VTWBSIA
X1 15 OUT4 SKQ2VTWBSIA
X2 17 16 SKJTL2J2
X3 16 14 SKJTL2J2T
X4 18 17 SKJTL2J2T
X5 7 18 SKJTL2J2
X6 21 19 8 SKPHGENC
X7 13 12 22 15 OUT5 OUT6 OUT7 SKDSYNA2X5D
X8 11 12 22 7 SKDEL10JJX2B
X9 0 23 8 9 SKCOIL5X3A
X10 11 10 SKJTL2J2I
X11 9 10 SKQNTA
X12 OUT1 21 25 24 SKREFFREQC
X13 25 13 SKDEL26JJA
.subckt SKDEL2JJSPA IN O2 O1
L0 O1 5 2.11pH
L1 9 IN 1.19pH
L2 4 7 1.19pH
L4 6 4 1.98pH
L5 4 8 1.98pH
L6 10 O2 2.11pH
X1 9 0 7 12 SKJO17L0
X2 10 0 8 13 SKJO10S
X3 6 0 5 11 SKJO10S
.ends SKDEL2JJSPA
.subckt SKJO09S 1 2 1 2
B1 1 2 3 jj1000 area=0.210
R0 1 2 1.333ohm
.ends SKJO09S
.subckt SKJO17L0 1 2 1 2
B1 1 2 3 jj1000 area=0.325
R0 1 2 0.884ohm
.ends SKJO17L0
.subckt SKJO07L0 1 2 1 2
B1 1 2 3 jj1000 area=0.186
R0 1 2 1.52ohm
.ends SKJO07L0
.subckt SKJO01L0 1 2 1 2
B1 1 2 3 jj1000 area=0.120
R0 1 2 2.321ohm
.ends SKJO01L0
.subckt SKJTL2J2 L R
I0 0 6 0.35mA
L1 L 8 1.97pH
L2 3 6 1.97pH
L3 6 7 1.97pH
L4 4 R 1.97pH
L5 9 0 .08pH
LP0 0 5 .08pH
X1 8 9 3 11 SKJO12S
X2 7 5 4 10 SKJO12S
.ends SKJTL2J2
.subckt SKDEL20SPT IN O1 O2
I1 0 8 0.419mA
I2 0 9 0.331mA
L0 13 IN 2.01pH
L1 8 10 2.035pH
L2 7 8 1.22pH
L3 O1 4 2.40pH
L4 4 5 5.41pH
L5 6 9 2.76pH
L6 9 11 1.97pH
L11 12 O2 1.975pH
X0 6 14 5 0 SKJO09S
X1 4 0 7 15 SKJO17L0
X2 12 16 11 0 SKJO12S
X3 10 0 13 17 SKJO12S
.ends SKDEL20SPT
.subckt SKBS2J2 IN JT
I0 0 3 0.179mA
L1 IN 5 1.975pH
L2 6 4 0.29pH
L3 3 7 1.26pH
L4 8 JT 1.975pH
L5 9 0 0.32pH
L6 10 0 0.16pH
X0 4 3 12 11 SKJO05L
X1 5 9 6 13 SKJO06S
X2 7 10 8 14 SKJO04S
.ends SKBS2J2
.subckt SKV2Q2OS Q QN DC_IN
I1 0 9 0.351mA
I2 0 7 0.109mA
K1 L_IN L1 .333
L1 6 4 18.26pH
L2 11 10 2.26pH
L3 10 12 3.21pH
L4 5 Q 2.05pH
L5 14 7 4.52pH
L7 8 QN 2.04pH
L9 9 10 2.80pH
L_IN DC_IN 13 1440pH
R0 13 0 45ohm
X1 4 0 11 15 SKJO11S0
X2 12 0 5 16 SKJO12S
X3 6 0 14 17 SKJO12S
X4 7 0 8 18 SKJO12S
.ends SKV2Q2OS
.subckt SKDSYNA2X5D in1 IN2 IN3 OUT4 OUT1 OUT2 OUT3
X0 8 SKDSYNPLTA
X1 9 SKDSYNPLTA
X2 10 SKDSYNPLTA
X3 11 SKDSYNPLTA
X4 34 OUT4 SKDSYNPLTM
X5 IN3 12 8 16 SKDSYNA
X6 12 13 34 17 SKDSYNA
X7 13 14 9 18 SKDSYNA
X8 14 15 10 19 SKDSYNA
X9 15 OUT1 11 20 SKDSYNA
X10 OUT1 SKDSYNPLTA
X11 IN2 21 16 25 SKDSYNA
X12 21 22 17 26 SKDSYNA
X13 22 23 18 27 SKDSYNA
X14 23 24 19 28 SKDSYNA
X15 24 OUT2 20 29 SKDSYNA
X16 OUT2 SKDSYNPLTA
X17 25 30 in1 SKDSYNCLA
X18 26 31 30 SKDSYNCLA
X19 27 32 31 SKDSYNCLA
X20 28 33 32 SKDSYNCLA
X21 29 OUT3 33 SKDSYNCLA
X22 OUT3 SKDSYNPLTA
.ends SKDSYNA2X5D
.subckt SKJO12S 1 2 1 2
B1 1 2 3 jj1000 area=0.251
R0 1 2 1.16ohm
.ends SKJO12S
.subckt SKJO10S 1 2 1 2
B1 1 2 3 jj1000 area=0.224
R0 1 2 1.29ohm
.ends SKJO10S
.subckt SKPHGENC IN OUT DCO
L0 DCO 7 52.66pH
L1 DCO 6 52.66pH
L2 DCO 5 52.66pH
L3 DCO 4 52.66pH
Lsh 11 0 45pH
Rsh DCO 11 10.01ohm
X1 IN 15 10 SKDEL20SPT
X2 10 14 9 SKDEL20SPT
X3 9 13 8 SKDEL20SPT
X4 8 12 OUT SKDEL20SPT
X5 15 7 SKJT3DRVA
X6 14 6 SKJT3DRVA
X7 13 5 SKJT3DRVA
X8 12 4 SKJT3DRVA
.ends SKPHGENC
.subckt SKCOIL5X3A IN_1 IN_2 IN_3 OUT
K1 Lin L3 1.
K2 Lin_3 Lin_4 0.9
L3 5 6 40pH
Lin IN_1 IN_2 1000pH
Lin_3 6 IN_3 20pH
Lin_4 5 OUT 20pH
.ends SKCOIL5X3A
.subckt SKJTL2J2I R L
I0 0 6 0.35mA
L1 L 8 1.97pH
L2 3 6 1.97pH
L3 6 7 1.97pH
L4 4 R 1.97pH
L5 9 0 .08pH
LP0 0 5 .08pH
X1 8 9 3 11 SKJO12S
X2 7 5 4 10 SKJO12S
.ends SKJTL2J2I
.subckt SKJO06S 1 2 1 2
B1 1 2 3 jj1000 area=0.175
R0 1 2 1.621ohm
.ends SKJO06S
.subckt SKJO04S 1 2 1 2
B1 1 2 3 jj1000 area=0.151
R0 1 2 1.821ohm
.ends SKJO04S
.subckt SKREFFREQC OUT2 OUT1 OUT3 DC_IN
X0 6 OUT1 SKT4CCA
X1 8 7 SKJTL2J2
X2 7 OUT3 SKJTL2J2
X3 9 OUT2 SKJTL2J2
X4 8 6 5 SKSPL2J2F
X5 11 10 5 9 SKRSA
X6 11 10 DC_IN SKV2Q2OS
.ends SKREFFREQC
.subckt SKJTL2J2U IN OUT
I0 0 6 0.35mA
L1 IN 5 1.97pH
L2 3 6 1.97pH
L3 6 7 1.97pH
L4 4 OUT 1.97pH
L5 8 0 .08pH
LP1 0 9 .08pH
X1 5 8 3 10 SKJO12S
X2 7 9 4 11 SKJO12S
.ends SKJTL2J2U
.subckt SKJTL2J2T IN OUT
I0 0 5 0.35mA
L1 IN 7 2.03pH
L2 3 5 2.03pH
L3 5 6 2.03pH
L4 4 OUT 2.00pH
X1 7 0 3 9 SKJO12S
X2 6 0 4 8 SKJO12S
.ends SKJTL2J2T
.subckt SKJO05L 1 2 1 2
B1 1 2 3 jj1000 area=0.1625
R0 1 2 1.721ohm
.ends SKJO05L
.subckt SKJT3DRVA IN OUT
I1 0 4 0.413mA
I2 0 5 0.438mA
I3 0 OUT 0.001mA
L1 IN 6 2.32pH
L2 7 4 2.13pH
L3 4 8 1.29pH
L4 9 5 2.08pH
L7 5 10 0.132pH
L8 11 OUT 1.37pH
X1 6 0 7 12 SKJO10S
X2 8 0 9 13 SKJO17L0
X3 3 0 11 15 SKJO17L0
X3a 3 0 10 14 SKJO17L0
.ends SKJT3DRVA
.subckt SKQ2VTWBSIA IN OUT
X0 3 OUT SKQ2VTHA
X1 IN 3 SKBS2J2
.ends SKQ2VTWBSIA
.subckt SKDEL2JJRC in1 O1
I0 0 5 0.35mA
L0 in1 7 1.975pH
L1 6 5 1.975pH
L2 5 4 1.975pH
L3 3 O1 1.975pH
X0 4 0 3 8 SKJO12S
X1 7 0 6 9 SKJO12S
.ends SKDEL2JJRC
.subckt SKDSYNCLA T0 OUT IN
I1 0 16 0.419mA
I2 0 8 0.331mA
I4 0 18 0.35mA
I5 0 17 0.35mA
L0 21 IN 2.01pH
L1 16 19 2.035pH
L2 13 16 1.22pH
L3 T0 6 2.40pH
L4 6 7 5.437pH
L5 15 8 2.76pH
L6 8 23 1.97pH
L7 18 14 2.05pH
L8 22 18 2.04pH
L11 11 10 4.38pH
L12 12 17 2.07pH
L13 17 20 2.06pH
L16 4 5 4.34pH
L17 9 OUT 2.02pH
X0 12 0 5 24 SKJO12S
X1 6 0 13 25 SKJO17L0
X2 14 0 4 26 SKJO12S
X3 7 0 15 27 SKJO09S
X4 9 0 20 28 SKJO12S
X5 19 0 21 29 SKJO12S
X6 10 0 22 30 SKJO12S
X7 23 0 11 31 SKJO12S
.ends SKDSYNCLA
.subckt SKDSYNPLTA INQ
L1 INQ 2 5.27pH
R1 2 0 3ohm
.ends SKDSYNPLTA
.subckt SKDEL26JJA L R
X0 L 3 SKJTL2J2CRI
X1 3 4 SKJTL2J2T
X2 4 5 SKJTL2J2S
X3 5 6 SKJTL2J2S
X4 7 6 SKJTL2J2T
X5 8 7 SKJTL2J2U
X6 8 9 SKJTL2J2T
X7 9 10 SKJTL2J2S
X8 10 11 SKJTL2J2S
X9 11 12 SKJTL2J2S
X10 12 13 SKJTL2J2S
X11 13 14 SKJTL2J2S
X12 14 R SKJTL2J2S
.ends SKDEL26JJA
.subckt SKQ2VTHA T V
B1 3 8 23 jj1000 area=0.224
B6 10 8 26 jj1000 area=0.198
B15 5 9 24 jj1000 area=0.120
B18 9 6 25 jj1000 area=0.151
I0 0 15 0.244mA
I1 0 4 .386mA
I5 0 9 0.152mA
I6 0 6 0.142mA
L0 7 8 1.053pH
L1 12 3 0.737pH
L2 3 4 1.86pH
L3 4 13 2.45pH
L4 4 5 2.76pH
L7 10 11 2.26pH
L8 11 16 1.85pH
L11 T 15 1.975p
L19 0 14 0.263pH
L27 5 11 2.00pH
L28 6 0 0.895pH
LP7 10 17 0.737pH
R0 3 8 1.29ohm
R2 5 6 0.449ohm
R2_0 10 8 1.48ohm
R3 9 6 1.406ohm
R4 9 V 10.0
X0 19 12 0 18 SKJO11S0
X1 0 13 21 20 SKJO13S0
X2 15 14 22 7 SKJO13S0
X3 0 16 28 27 SKJO16S0
X4 17 30 29 0 SKJO07L0
.ends SKQ2VTHA
.subckt SKJTL2J2S IN OUT
I0 0 7 0.35mA
L1 IN 3 1.97pH
L2 4 7 1.97pH
L3 7 8 1.97pH
L4 5 OUT 1.97pH
L5 9 0 .08pH
LP0 0 6 .08pH
X1 3 9 4 11 SKJO12S
X2 8 6 5 10 SKJO12S
.ends SKJTL2J2S
.subckt SKQNTA IN OUT
I1 0 3 0.138mA
L1 9 IN 0.965pH
L2 3 7 5.974pH
L3 OUT 4 2.918pH
LP1 6 3 0.097pH
Lpx1 8 0 .059pH
Lpx2 5 0 .094pH
X1 6 5 4 10 SKJO07L0
X2 9 8 7 11 SKJO01L0
.ends SKQNTA
.subckt SKDSYNPLTM IN OUT
I0 0 4 0.175mA
L0 OUT 3 2.658pH
L1 4 IN 2.042pH
X0 4 0 3 5 SKJO12S
.ends SKDSYNPLTM
.subckt SKDEL10JJX2B in1 OUT1 OUT2 OUT3
X0 OUT3 10 9 6 SKDEL2X2JJR
X1 10 5 7 9 SKDEL2X2JJR
X2 7 5 OUT2 SKDEL2JJSPA
X3 13 6 SKDEL2JJRC
X4 8 14 SKDEL2JJRC
X5 11 8 OUT1 SKDEL2JJSPA
X6 in1 12 SKJTL2J2
X7 12 11 SKJTL2J2
.ends SKDEL10JJX2B
.subckt SKJO13S0 1 2 2 1
B1 1 2 3 jj1000 area=0.264
R0 1 2 1.09ohm
.ends SKJO13S0
.subckt SKJO20S0 1 2 1 2
B1 1 2 3 jj1000 area=0.3725
R0 1 2 0.782ohm
.ends SKJO20S0
.subckt SKDEL2X2JJR IN2 O2 in1 O1
I0 0 9 0.35mA
I1 0 10 0.33125mA
L0 in1 13 1.975pH
L1 11 9 1.975pH
L2 9 7 1.975pH
L3 5 O1 1.975pH
L4 6 IN2 1.975pH
L5 10 8 1.975pH
L6 12 10 1.975pH
L7 O2 14 1.975pH
X0 7 0 5 15 SKJO12S
X2 13 0 11 17 SKJO12S
X3 14 0 12 18 SKJO12S
X4 8 0 6 16 SKJO12S
.ends SKDEL2X2JJR
.subckt SKJO11S0 1 2 1 2
B1 1 2 3 jj1000 area=0.238
R0 1 2 1.20ohm
.ends SKJO11S0
.subckt SKJO16S0 1 2 1 2
B1 1 2 3 jj1000 area=0.310
R0 1 2 0.93ohm
.ends SKJO16S0
.subckt SKT4CCA T QN
I1 0 6 .176mA
I1_0 0 9 .248mA
L0 T 12 1.975pH
L2 9 7 1.18pH
L3 7 13 0.74pH
L4 8 6 6.45pH
L5 3 11 0.40pH
L6 4 5 0.32pH
L7 3 10 0.11pH
L8 3 6 0.29pH
L9 5 QN 1.975pH
L15 5 8 0.08pH
X0 12 0 20 9 SKJO13S0
X1 22 21 13 8 SKJO06S
X2 7 11 19 18 SKJO12S
X3 4 0 17 16 SKJO11S0
X4 15 14 10 0 SKJO15S0
.ends SKT4CCA
.subckt SKDSYNA IN OUT TO T1
I1 0 23 0.4375mA
I2 0 18 0.45mA
I3 0 11 0.344mA
L0 IN 21 1.975pH
L1 23 24 0.843pH
L2 19 9 5.00pH
L3 9 OUT 2.633pH
L4 8 25 4.08pH
L5 10 T1 1.975pH
L6 18 7 1.87pH
L7 TO 14 2.45pH
L10 14 12 5.61pH
L12 13 17 0.87pH
L16 22 23 1.975pH
L19 5 11 1.82pH
L20 0 15 0.26pH
L22 6 18 1.11pH
L25 5 16 0.224pH
L27 20 0 0.26pH
X0 21 0 22 35 SKJO10S
X1 24 0 8 36 SKJO20S0
X2 25 0 9 37 SKJO20S0
X3 5 19 33 32 SKJO11S0
X4 10 20 7 34 SKJO12S
X5 6 15 14 27 SKJO17L0
X6 0 13 26 12 SKJO09S
X7 5 17 31 30 SKJO09S
X8 16 0 29 28 SKJO12S
.ends SKDSYNA
.subckt SKJTL2J2CRI IN OUT
I0 0 3 0.175mA
I1 0 4 0.175mA
L1 IN 5 1.97pH
L2 3 6 1.97pH
L3 6 7 1.97pH
L4 4 OUT 1.97pH
L5 8 0 .08pH
LP1 0 9 .08pH
X1 5 8 3 10 SKJO12S
X2 7 9 4 11 SKJO12S
.ends SKJTL2J2CRI
.subckt SKRSA S R RO SO
I0 0 6 0.261mA
L1 R 10 1.45pH
L2 8 RO 2.20pH
L3 S 9 1.40pH
L4 7 5 7.523pH
L5 6 SO 2.24pH
X1 15 14 10 7 SKJO09S
X2 7 0 8 16 SKJO11S0
X3 9 5 12 11 SKJO09S
X4 5 0 6 13 SKJO11S0
.ends SKRSA
.subckt SKSPL2J2F OUT1 OUT2 IN
I0 0 6 0.448mA
L0 5 OUT1 2.71pH
L1 IN 7 1.95pH
L2 4 6 2.00pH
L3 6 8 1.45pH
L4 5 OUT2 2.71pH
X1 7 0 4 9 SKJO12S
X2 8 0 5 10 SKJO17L0
.ends SKSPL2J2F
.subckt SKJO15S0 2 1 1 2
B1 1 2 3 jj1000 area=0.294
R0 1 2 0.98ohm
.ends SKJO15S0
.save @I0.X5.X13[c]
.save @I0.X12.X13[c]
.save @I0.X11.X13[c]
.save @I0.X10.X13[c]
.save @I0.X9.X13[c]
.save @I0.X7.X13[c]
.save @I0.X8.X13[c]
.save @I0.X3.X13[c]
.save @I0.X2.X13[c]
.save @I0.X6.X13[c]
.save @I0.X4.X13[c]
.save @I0.X1.X13[c]
.save @I1.X0.X13[c]
.save @I0.X0.X13[c]
.save @I0.X4[c]
.save @I0.X3[c]
.save @I0.X1.X0[c]
.save @I5.X0.X0[c]
.save @I6.X0.X0[c]
.save @I1.X0.X0[c]
.save @I0.X0.X0[c]
.save @I0.X1.X1[c]
.save @I5.X0.X1[c]
.save @I6.X0.X1[c]
.save @I1.X0.X1[c]
.save @I0.X0.X1[c]
.save @I0.X4.X8[c]
.save @I0.X3.X8[c]
.save @I1.X1.X8[c]
.save @I0.X1.X8[c]
.save @I1.X0.X8[c]
.save @I0.X0.X8[c]
.save @I0.X7.X8[c]
.save @I0.X6.X8[c]
.save @I0.X4.X12[c]
.save @I1.X0.X12[c]
.save @I1_0.X0.X12[c]
.save @I2.X6.X12[c]
.save @I1.X6.X12[c]
.save @I0.X5.X12[c]
.save @I0.X2.X12[c]
.save @I0.X1.X12[c]
.save @I0.X3.X12[c]
.save @I1.X11[c]
.save @I0.X4.X7[c]
.save @I4.X21.X7[c]
.save @I2.X21.X7[c]
.save @I5.X21.X7[c]
.save @I1.X21.X7[c]
.save @I4.X20.X7[c]
.save @I2.X20.X7[c]
.save @I5.X20.X7[c]
.save @I1.X20.X7[c]
.save @I4.X19.X7[c]
.save @I2.X19.X7[c]
.save @I5.X19.X7[c]
.save @I1.X19.X7[c]
.save @I4.X18.X7[c]
.save @I2.X18.X7[c]
.save @I5.X18.X7[c]
.save @I1.X18.X7[c]
.save @I4.X17.X7[c]
.save @I2.X17.X7[c]
.save @I5.X17.X7[c]
.save @I1.X17.X7[c]
.save @I2.X15.X7[c]
.save @I3.X15.X7[c]
.save @I1.X15.X7[c]
.save @I2.X13.X7[c]
.save @I3.X13.X7[c]
.save @I1.X13.X7[c]
.save @I2.X12.X7[c]
.save @I3.X12.X7[c]
.save @I1.X12.X7[c]
.save @I2.X6.X7[c]
.save @I3.X6.X7[c]
.save @I1.X6.X7[c]
.save @I2.X11.X7[c]
.save @I3.X11.X7[c]
.save @I1.X11.X7[c]
.save @I2.X8.X7[c]
.save @I3.X8.X7[c]
.save @I1.X8.X7[c]
.save @I2.X14.X7[c]
.save @I3.X14.X7[c]
.save @I1.X14.X7[c]
.save @I2.X9.X7[c]
.save @I3.X9.X7[c]
.save @I1.X9.X7[c]
.save @I2.X7.X7[c]
.save @I3.X7.X7[c]
.save @I1.X7.X7[c]
.save @I2.X5.X7[c]
.save @I3.X5.X7[c]
.save @I1.X5.X7[c]
.save @I0.X5[c]
.save @I0.X2[c]
.save @I2.X1.X6[c]
.save @I1.X1.X6[c]
.save @I2.X2.X6[c]
.save @I1.X2.X6[c]
.save @I2.X3.X6[c]
.save @I1.X3.X6[c]
.save @I2.X4.X6[c]
.save @I1.X4.X6[c]
.save @I3.X5.X6[c]
.save @I2.X5.X6[c]
.save @I1.X5.X6[c]
.save @I3.X6.X6[c]
.save @I2.X6.X6[c]
.save @I1.X6.X6[c]
.save @I3.X7.X6[c]
.save @I2.X7.X6[c]
.save @I1.X7.X6[c]
.save @I3.X8.X6[c]
.save @I2.X8.X6[c]
.save @I1.X8.X6[c]
.save @I0.X10[c]
.save @I1[c]
.save @Isig[c]
